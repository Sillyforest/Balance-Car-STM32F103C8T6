# Keil uVision project LIB.ku.uvprojx, settings and files
target LED (ARM-ADS)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.0.0
  cpu: IROM(0x08000000,0x10000) IRAM(0x20000000,0x5000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: STM32F103LIB +hex
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: STM32F10X_MD,USE_STDPERIPH_DRIVER
  c include: ..\USER;..\CORE;..\STM32F10x_FWLib\inc;..\SYSTEM\sys;..\SYSTEM\usart;..\LIB;..\BALANCE\CONTROL;..\BALANCE\DataScope_DP;..\BALANCE\show;..\usart;..\SYSTEM\sys\sys\delay;..\SYSTEM\sys\sys\sys;..\LIB;..\LIB\MPU6050;..\LIB\DMP;..\LIB\IIC
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group USER
    ../LIB/: TIMERandEXTIX.c STM32F103LIB.lib
    ./: main.c pid.c
  group LIB
    ./: stm32f10x_it.c system_stm32f10x.c
    ../LIB/DMP/: inv_mpu.c inv_mpu_dmp_motion_driver.c
    ../LIB/IIC/: IOI2C.c
    ../LIB/MPU6050/: MPU6050.c
  group yuanzilib
    ../STM32F10x_FWLib/src/: misc.c stm32f10x_adc.c stm32f10x_exti.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_rcc.c
    ../CORE/: core_cm3.c startup_stm32f10x_hd.s
  group New Group
    ../SYSTEM/sys/sys/delay/: delay.c
    ../SYSTEM/sys/sys/sys/: sys.c
